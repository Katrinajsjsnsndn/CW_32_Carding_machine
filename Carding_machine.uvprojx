# Keil uVision project Carding_machine.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CW32L011K8 WHXY
  pack: WHXY.CW32L011_DFP.1.0.1
  cpu: IRAM(0x20000000,0x01800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Carding_machine
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Startup;.\Libraries\inc;.\USER\inc;.\StartKit_Board
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Startup
    ./Startup/: startup_cw32l011.s system_cw32l011.c
  group User
    ./USER/src/: interrupts_cw32l011.c main.c wifi_comm.c mqtt_client.c my_init.c
  group Drivers
    ./Libraries/src/: cw32l011_flash.c cw32l011_gpio.c cw32l011_sysctrl.c cw32l011_adc.c cw32l011_atim.c cw32l011_btim.c cw32l011_crc.c cw32l011_debug.c cw32l011_digitalsign.c cw32l011_gtim.c cw32l011_i2c.c cw32l011_iwdt.c cw32l011_lptim.c cw32l011_lvd.c cw32l011_pwr.c cw32l011_ram.c cw32l011_rtc.c cw32l011_spi.c cw32l011_systick.c cw32l011_uart.c cw32l011_vc.c i2c_eeprom.c
  group Bsp
    ./StartKit_Board/: cw32l011_startkit_board.c
software components: CMSIS:CORE 5.6.0
